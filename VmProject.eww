<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\anony\anony.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\darksecure\darksecure.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lottery\lottery.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\p2pBet\p2pbet.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SecuredTrade\SecuredTrade.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\unit_test\unit_test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


